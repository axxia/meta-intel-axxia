require linux-axxia.inc
require linux-yocto_${KERNEL_MAJOR_VERSION}.inc

LINUX_VERSION_EXTENSION = "-yocto-axxia-${LINUX_KERNEL_TYPE}"

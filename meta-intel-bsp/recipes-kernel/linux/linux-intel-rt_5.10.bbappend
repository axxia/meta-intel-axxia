require linux-axxia.inc
require linux-intel_${KERNEL_MAJOR_VERSION}.inc

LINUX_VERSION_EXTENSION = "-intel-axxia-${LINUX_KERNEL_TYPE}"

# Include upstream commit to fix symbol_why for v6.18-rc1+
SRCREV = "f589e1df23251d8319063da0a61c1016b2a0bf85"

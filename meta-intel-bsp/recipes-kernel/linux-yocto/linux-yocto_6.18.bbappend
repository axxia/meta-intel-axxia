require recipes-kernel/linux/linux-axxia.inc
require linux-yocto_6.18.inc

LINUX_VERSION_EXTENSION = "-yocto-axxia-${LINUX_KERNEL_TYPE}"

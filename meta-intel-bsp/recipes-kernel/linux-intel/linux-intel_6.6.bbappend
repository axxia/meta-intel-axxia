require recipes-kernel/linux/linux-axxia.inc
require linux-intel_6.6.inc

LINUX_VERSION_EXTENSION = "-intel-axxia-${LINUX_KERNEL_TYPE}"

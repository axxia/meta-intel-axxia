KBRANCH_axxiax86-64 = "standard/base"
SRCREV_machine_axxiax86-64 = "81034b38737e13dacf23b59e9ce34a06b6bea350"
SRCREV_meta_axxiax86-64 = "12333728637b4fc73c48cc742e444cb5f60485fd"

LINUX_VERSION_axxiax86-64 = "4.12.29"

LINUX_KERNEL_TYPE = "standard"

require linux-yocto-4.12.inc

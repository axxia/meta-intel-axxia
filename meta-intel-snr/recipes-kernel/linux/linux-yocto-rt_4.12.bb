KBRANCH_axxiax86-64 = "standard/preempt-rt/base"
SRCREV_machine_axxiax86-64 = "930622b5cdb1fea9cad09ced7a53b385bdcccaee"
SRCREV_meta_axxiax86-64 = "12333728637b4fc73c48cc742e444cb5f60485fd"

LINUX_VERSION_axxiax86-64 = "4.12.29"

LINUX_KERNEL_TYPE = "preempt-rt"

require linux-yocto-4.12.inc

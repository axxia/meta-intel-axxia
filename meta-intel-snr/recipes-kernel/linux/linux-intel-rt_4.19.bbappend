require linux-axxia.inc
require linux-intel_${KERNEL_MAJOR_VERSION}.inc

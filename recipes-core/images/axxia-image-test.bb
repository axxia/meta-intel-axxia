require axxia-image-large.bb

IMAGE_INSTALL_append = " ltp"

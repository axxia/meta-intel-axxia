SRC_URI = "https://archive.apache.org/dist/${BPN}/${PV}/${BPN}-${PV}.tar.gz"

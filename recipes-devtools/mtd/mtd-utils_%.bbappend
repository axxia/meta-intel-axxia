FILES_mtd-utils-misc += " ${sbindir}/mtd_debug"

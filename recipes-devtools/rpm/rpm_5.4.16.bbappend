FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://rpm-update-to-support-db-6.2.23.patch"

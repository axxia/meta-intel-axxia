COMPATIBLE_HOST_append = '|aarch64.*-linux'

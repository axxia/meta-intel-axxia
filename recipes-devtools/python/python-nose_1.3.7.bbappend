RDEPENDS_${PN}_append = " python-distribute"

FILESEXTRAPATHS_prepend := "${THISDIR}/gnu-efi:"
SRC_URI_append_axxiax86-64 = "file://0001-Add-GUID-for-SMBIOS-3-entry-point-structure.patch"
PACKAGE_ARCH_axxiax86-64 = "${INTEL_COMMON_PACKAGE_ARCH}"

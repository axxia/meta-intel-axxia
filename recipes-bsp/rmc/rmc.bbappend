FILES_${PN}-staticdev += "/usr/lib"

SYSROOT_DIRS_append += "/usr/lib"

BBCLASSEXTEND = "native nativesdk"

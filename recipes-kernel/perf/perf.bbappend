DEPENDS_append = " virtual/kernel"

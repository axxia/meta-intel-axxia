RDEPENDS_${PN}-ptest_remove = "libmodule-build-perl"
RRECOMMENDS_${PN}-ptest += "libmodule-build-perl"

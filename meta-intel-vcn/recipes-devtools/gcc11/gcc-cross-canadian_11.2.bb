require recipes-devtools/gcc11/gcc-${PV}.inc
require gcc-cross-canadian.inc




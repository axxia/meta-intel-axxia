SRC_URI = "https://wireshark.marwan.ma/download/src/all-versions/${BP}.tar.xz"

UPSTREAM_CHECK_URI = "https://wireshark.marwan.ma/download/src"

SRC_URI = "http://salsa.debian.org/iso-codes-team/iso-codes.git;protocol=http"

require recipes-core/images/axxia-image-min.bb
require axxia-efistub.inc

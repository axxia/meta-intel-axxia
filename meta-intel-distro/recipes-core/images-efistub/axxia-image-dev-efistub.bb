require recipes-core/images/axxia-image-dev.bb
require axxia-efistub.inc

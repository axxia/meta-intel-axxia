require recipes-core/images/axxia-image-qsp.bb
require axxia-efistub.inc

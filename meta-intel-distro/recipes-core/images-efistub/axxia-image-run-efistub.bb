require recipes-core/images/axxia-image-run.bb
require axxia-efistub.inc

require axxia-image-dev-efistub.bb
require axxia-efistub-signed.inc

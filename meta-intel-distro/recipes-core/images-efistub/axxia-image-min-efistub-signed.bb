require axxia-image-min-efistub.bb
require axxia-efistub-signed.inc

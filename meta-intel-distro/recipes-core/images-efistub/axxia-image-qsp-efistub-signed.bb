require axxia-image-qsp-efistub.bb
require axxia-efistub-signed.inc

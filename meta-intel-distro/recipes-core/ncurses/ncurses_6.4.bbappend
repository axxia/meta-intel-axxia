BUILDSDK_CFLAGS += "-std=gnu17" 

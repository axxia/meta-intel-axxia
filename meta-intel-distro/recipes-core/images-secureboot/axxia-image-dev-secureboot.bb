require recipes-core/images/axxia-image-dev.bb
require axxia-secureboot.inc

require axxia-image-min-secureboot.bb
require axxia-secureboot-signed.inc

require axxia-image-run-secureboot.bb
require axxia-secureboot-signed.inc

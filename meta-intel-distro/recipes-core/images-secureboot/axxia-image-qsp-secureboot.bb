require recipes-core/images/axxia-image-qsp.bb
require axxia-secureboot.inc

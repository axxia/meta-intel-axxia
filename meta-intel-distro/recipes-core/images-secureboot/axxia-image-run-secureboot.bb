require recipes-core/images/axxia-image-run.bb
require axxia-secureboot.inc

require axxia-image-dev-secureboot.bb
require axxia-secureboot-signed.inc

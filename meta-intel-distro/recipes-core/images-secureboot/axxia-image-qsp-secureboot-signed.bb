require axxia-image-qsp-secureboot.bb
require axxia-secureboot-signed.inc

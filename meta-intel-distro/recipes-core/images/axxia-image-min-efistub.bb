require axxia-image-min.bb
require axxia-efistub.inc

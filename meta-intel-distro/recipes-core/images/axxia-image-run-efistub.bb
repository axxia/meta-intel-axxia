require axxia-image-run.bb
require axxia-efistub.inc

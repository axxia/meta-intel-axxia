require axxia-image-dev.bb
require axxia-efistub.inc

require axxia-image-run-efistub.bb
require axxia-efistub-signed.inc

require axxia-image-qsp.bb
require axxia-efistub.inc

RDEPENDS:${PN}-ptest:remove = "libmodule-build-perl"
RRECOMMENDS:${PN}-ptest += "libmodule-build-perl"

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI:append = " file://0001-Fix-build-errors-related-to-incorrect-function-param.patch"

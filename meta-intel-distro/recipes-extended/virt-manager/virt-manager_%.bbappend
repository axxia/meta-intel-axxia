# No GUI suported
PACKAGECONFIG ?= ""

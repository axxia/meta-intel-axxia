ALTERNATIVE_KERNEL_NUMBER = "0"

require recipes-kernel/lttng/lttng-modules_${PV}.bb
require lttng-modules-alternative.inc

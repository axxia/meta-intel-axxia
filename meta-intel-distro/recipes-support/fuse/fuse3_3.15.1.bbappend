FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI:append = " file://0001-Wrapper-around-test-applications-for-cross-compiler.patch"

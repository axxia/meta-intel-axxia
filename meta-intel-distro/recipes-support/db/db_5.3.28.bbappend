# -Wno-error=incompatible-pointer-types needed for gcc-15
CFLAGS += "-Wno-error=incompatible-pointer-types"
BUILD_CFLAGS += "-Wno-error=incompatible-pointer-types"

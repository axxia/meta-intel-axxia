# Not yet ready for C23
BUILDSDK_CFLAGS += "-std=gnu11"

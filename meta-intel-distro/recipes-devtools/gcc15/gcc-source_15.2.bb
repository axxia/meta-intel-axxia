require recipes-devtools/gcc15/gcc-${PV}.inc
require recipes-devtools/gcc15/gcc-source.inc

BPN = "gcc-source"
EXCLUDE_FROM_WORLD = "1"

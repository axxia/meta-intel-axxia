require recipes-devtools/gcc15/gcc-${PV}.inc
require gcc-cross-canadian.inc




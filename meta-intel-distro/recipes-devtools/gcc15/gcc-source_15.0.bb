require recipes-devtools/gcc15/gcc-${PV}.inc
require recipes-devtools/gcc15/gcc-source.inc

EXCLUDE_FROM_WORLD = "1"

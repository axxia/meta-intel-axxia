require recipes-devtools/gcc15/gcc-cross_${PV}.bb
require gcc-crosssdk.inc

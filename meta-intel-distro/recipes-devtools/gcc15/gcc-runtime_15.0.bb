require recipes-devtools/gcc15/gcc-${PV}.inc
require gcc-runtime.inc

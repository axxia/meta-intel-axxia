inherit multilib_script

MULTILIB_SCRIPTS = "${PN}:${bindir}/vala-gen-introspect-0.56 \
		   "

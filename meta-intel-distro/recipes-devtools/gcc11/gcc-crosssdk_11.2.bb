require recipes-devtools/gcc11/gcc-cross_${PV}.bb
require gcc-crosssdk.inc

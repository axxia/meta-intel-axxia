require recipes-devtools/gcc11/gcc-${PV}.inc
require libgfortran.inc


require recipes-devtools/gcc11/gcc-${PV}.inc
require recipes-devtools/gcc11/gcc-source.inc

EXCLUDE_FROM_WORLD = "1"

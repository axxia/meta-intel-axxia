require recipes-devtools/gcc11/gcc-${PV}.inc
require gcc-runtime.inc

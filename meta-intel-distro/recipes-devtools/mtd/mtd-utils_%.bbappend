FILES:mtd-utils-misc += " ${sbindir}/mtd_debug"

BBCLASSEXTEND_append = " nativesdk"

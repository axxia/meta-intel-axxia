DESCRIPTION = "Universal Python binding for the LMDB 'Lightning' Database"
SECTION = "devel/python"
HOMEPAGE = "https://github.com/jnwatson/py-lmdb"
LICENSE = "OpenLDAP"
LIC_FILES_CHKSUM = "file://LICENSE;md5=153d07ef052c4a37a8fac23bc6031972"

inherit pypi setuptools3

SRC_URI[md5sum] = "3c955c49be10a7a07a2fcd54d180c3af"
SRC_URI[sha256sum] = "60a11efc21aaf009d06518996360eed346f6000bfc9de05114374230879f992e"

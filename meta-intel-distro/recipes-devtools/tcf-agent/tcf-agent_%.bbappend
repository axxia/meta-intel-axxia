SYSTEMD_AUTO_ENABLE = "disable"

# Do not start tcf-agent automatically at boot on sysvinit
INITSCRIPT_PARAMS = "stop 20 0 1 2 3 5 6 ."

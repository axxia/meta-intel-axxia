PACKAGECONFIG:append = " virtfs libusb"

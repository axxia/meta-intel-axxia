require recipes-devtools/gcc9/gcc-${PV}.inc
require libgfortran.inc


require recipes-devtools/gcc9/gcc-${PV}.inc
require recipes-devtools/gcc9/gcc-source.inc

EXCLUDE_FROM_WORLD = "1"

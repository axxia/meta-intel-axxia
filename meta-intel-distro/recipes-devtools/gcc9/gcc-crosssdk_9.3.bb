require recipes-devtools/gcc9/gcc-cross_${PV}.bb
require gcc-crosssdk.inc

FILES:${PN}-dev += "${nonarch_libdir}/cmake"

require axxia-image-rdk.inc

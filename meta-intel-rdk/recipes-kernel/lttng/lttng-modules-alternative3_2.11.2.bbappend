require lttng-modules-rdk.inc

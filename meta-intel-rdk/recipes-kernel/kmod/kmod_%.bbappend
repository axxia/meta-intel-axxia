require ${@oe.utils.conditional('MACHINE', 'intel-axxia-pmr', '', 'kmod-rdk.inc', d)}

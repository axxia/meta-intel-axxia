require ${@oe.utils.conditional('MACHINE', 'intel-axxia-pmr', '', 'linux-rdk.inc', d)}

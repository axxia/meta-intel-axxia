PACKAGECONFIG_remove = " polkit"

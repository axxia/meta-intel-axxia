ALTERNATIVE_KERNEL_NUMBER = "1"

require recipes-kernel/lttng/lttng-modules_${PV}.bb
require lttng-modules-alternative.inc

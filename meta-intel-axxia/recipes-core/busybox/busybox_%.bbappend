FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_append_axxiax86-64 = " file://enable_tftp_blocksize_feature.cfg"

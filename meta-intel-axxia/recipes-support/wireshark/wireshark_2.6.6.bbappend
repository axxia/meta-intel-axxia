EXTRA_OECMAKE += " -DM_LIBRARY=${nonarch_libdir}"
